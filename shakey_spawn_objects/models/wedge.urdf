Commit message: some clean up

File: shakey_spawn_objects/models/wedge.urdf (robot description, URDF)
Before this commit: robot wedge_model, 1 links, 0 joints
Links:
- link wedge: mass 1.000000 -> 5.000000
